Commit message: Fix visual of calibration mire.

File: urdf/calibration_mire.urdf (robot description, URDF)
Before this commit: robot calibration_mire, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.5 0.3 0.002; visual box size=0.5 0.3 0.001
